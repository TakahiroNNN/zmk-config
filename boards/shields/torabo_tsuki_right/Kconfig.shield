## boards/shields/torabo_tsuki_right/Kconfig.shield
```kconfig
config SHIELD_TORABO_TSUKI_LEFT
    def_bool $(shields_list_contains,torabo_tsuki_left)
```
